# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: JERRY_ENABLE_ERROR_MESSAGES, USE_HAL_DRIVER, CONFIG_DISABLE_ES2015, JERRY_ENABLE_EXTERNAL_CONTEXT, STM32F429xx, RT_USING_ARM_LIBC, JERRY_JS_PARSER
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;board\ports\spi_flash;board\ports\fal_config;board\ports\sdram;board\ports\lcd;board\ports\spi;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;packages\fal-latest\inc;packages\jerryscript-latest;packages\jerryscript-latest\jerryscript\jerry-core\api;packages\jerryscript-latest\jerryscript\jerry-core\debugger;packages\jerryscript-latest\jerryscript\jerry-core\ecma\base;packages\jerryscript-latest\jerryscript\jerry-core\ecma\builtin-objects;packages\jerryscript-latest\jerryscript\jerry-core\ecma\builtin-objects\typedarray;packages\jerryscript-latest\jerryscript\jerry-core\ecma\operations;packages\jerryscript-latest\jerryscript\jerry-core\include;packages\jerryscript-latest\jerryscript\jerry-core\jcontext;packages\jerryscript-latest\jerryscript\jerry-core\jmem;packages\jerryscript-latest\jerryscript\jerry-core\jrt;packages\jerryscript-latest\jerryscript\jerry-core\lit;packages\jerryscript-latest\jerryscript\jerry-core\parser\js;packages\jerryscript-latest\jerryscript\jerry-core\parser\regexp;packages\jerryscript-latest\jerryscript\jerry-core\vm;packages\jerryscript-latest\jerryscript\jerry-ext\arg;packages\jerryscript-latest\jerryscript\jerry-ext\handler;packages\jerryscript-latest\jerryscript\jerry-ext\include;packages\jerryscript-latest\jerryscript\jerry-ext\module;packages\jerryscript-latest\rtthread-port;packages\LVGL-v8.3-latest\env_support\rt-thread;packages\LVGL-v8.3-latest\src;packages\LVGL-v8.3-latest\src\core;packages\LVGL-v8.3-latest\src\draw;packages\LVGL-v8.3-latest\src\extra;packages\LVGL-v8.3-latest\src\font;packages\LVGL-v8.3-latest\src\hal;packages\LVGL-v8.3-latest\src\misc;packages\LVGL-v8.3-latest\src\widgets;packages\LVGL-v8.3-latest\src\draw\arm2d;packages\LVGL-v8.3-latest\src\draw\nxp;packages\LVGL-v8.3-latest\src\draw\sdl;packages\LVGL-v8.3-latest\src\draw\stm32_dma2d;packages\LVGL-v8.3-latest\src\draw\sw;packages\LVGL-v8.3-latest\src\draw\swm341_dma2d;packages\LVGL-v8.3-latest\src\draw\nxp\pxp;packages\LVGL-v8.3-latest\src\draw\nxp\vglite;packages\LVGL-v8.3-latest\src\extra\layouts;packages\LVGL-v8.3-latest\src\extra\libs;packages\LVGL-v8.3-latest\src\extra\others;packages\LVGL-v8.3-latest\src\extra\themes;packages\LVGL-v8.3-latest\src\extra\widgets;packages\LVGL-v8.3-latest\src\extra\layouts\flex;packages\LVGL-v8.3-latest\src\extra\layouts\grid;packages\LVGL-v8.3-latest\src\extra\libs\bmp;packages\LVGL-v8.3-latest\src\extra\libs\ffmpeg;packages\LVGL-v8.3-latest\src\extra\libs\freetype;packages\LVGL-v8.3-latest\src\extra\libs\fsdrv;packages\LVGL-v8.3-latest\src\extra\libs\gif;packages\LVGL-v8.3-latest\src\extra\libs\png;packages\LVGL-v8.3-latest\src\extra\libs\qrcode;packages\LVGL-v8.3-latest\src\extra\libs\rlottie;packages\LVGL-v8.3-latest\src\extra\libs\sjpg;packages\LVGL-v8.3-latest\src\extra\others\fragment;packages\LVGL-v8.3-latest\src\extra\others\gridnav;packages\LVGL-v8.3-latest\src\extra\others\ime;packages\LVGL-v8.3-latest\src\extra\others\imgfont;packages\LVGL-v8.3-latest\src\extra\others\monkey;packages\LVGL-v8.3-latest\src\extra\others\msg;packages\LVGL-v8.3-latest\src\extra\others\snapshot;packages\LVGL-v8.3-latest\src\extra\themes\basic;packages\LVGL-v8.3-latest\src\extra\themes\default;packages\LVGL-v8.3-latest\src\extra\themes\mono;packages\LVGL-v8.3-latest\src\extra\widgets\animimg;packages\LVGL-v8.3-latest\src\extra\widgets\calendar;packages\LVGL-v8.3-latest\src\extra\widgets\chart;packages\LVGL-v8.3-latest\src\extra\widgets\colorwheel;packages\LVGL-v8.3-latest\src\extra\widgets\imgbtn;packages\LVGL-v8.3-latest\src\extra\widgets\keyboard;packages\LVGL-v8.3-latest\src\extra\widgets\led;packages\LVGL-v8.3-latest\src\extra\widgets\list;packages\LVGL-v8.3-latest\src\extra\widgets\menu;packages\LVGL-v8.3-latest\src\extra\widgets\meter;packages\LVGL-v8.3-latest\src\extra\widgets\msgbox;packages\LVGL-v8.3-latest\src\extra\widgets\span;packages\LVGL-v8.3-latest\src\extra\widgets\spinbox;packages\LVGL-v8.3-latest\src\extra\widgets\spinner;packages\LVGL-v8.3-latest\src\extra\widgets\tabview;packages\LVGL-v8.3-latest\src\extra\widgets\tileview;packages\LVGL-v8.3-latest\src\extra\widgets\win;packages\LVGL-v8.3-latest\demos;packages\LVGL-v8.3-latest\demos\benchmark;packages\LVGL-v8.3-latest\demos\keypad_encoder;packages\LVGL-v8.3-latest\demos\music;packages\LVGL-v8.3-latest\demos\stress;packages\LVGL-v8.3-latest\demos\widgets;packages\LVGL-v8.3-latest\demos\music\assets;packages\minIni-v1.2.0\dev;packages\ota_downloader-latest;packages\xpt2046-latest;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\utilities\mod_dac;..\..\..\components\utilities\mod_input;..\..\..\components\utilities\mod_para;..\..\..\components\utilities\utils_list;..\..\..\components\utilities\ymodem;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/spi_flash/: spi_flash_init.c
    board/ports/fal_config/: fal_flash_sfud_port.c fal_filesystem_init.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_spi.c drv_sdram.c drv_lcd.c drv_sdio.c drv_usbd.c drv_pulse_encoder.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group JerryScript
    packages/jerryscript-latest/jerryscript/jerry-core/api/: jerry-debugger-transport.c jerry-debugger.c jerry-snapshot.c jerry.c
    packages/jerryscript-latest/jerryscript/jerry-core/debugger/: debugger.c
    packages/jerryscript-latest/jerryscript/jerry-core/ecma/base/: ecma-alloc.c ecma-gc.c ecma-helpers-conversion.c ecma-helpers-errol.c ecma-helpers-external-pointers.c ecma-helpers-number.c ecma-helpers-string.c ecma-helpers-value.c ecma-helpers-values-collection.c ecma-helpers.c ecma-init-finalize.c ecma-lcache.c ecma-literal-storage.c ecma-property-hashmap.c
    packages/jerryscript-latest/jerryscript/jerry-core/ecma/builtin-objects/: ecma-builtin-array-prototype.c ecma-builtin-array.c ecma-builtin-arraybuffer-prototype.c ecma-builtin-arraybuffer.c ecma-builtin-boolean-prototype.c ecma-builtin-boolean.c ecma-builtin-date-prototype.c ecma-builtin-date.c ecma-builtin-error-prototype.c ecma-builtin-error.c ecma-builtin-evalerror-prototype.c ecma-builtin-evalerror.c ecma-builtin-function-prototype.c ecma-builtin-function.c ecma-builtin-global.c ecma-builtin-helpers-date.c ecma-builtin-helpers-error.c ecma-builtin-helpers-json.c ecma-builtin-helpers-sort.c ecma-builtin-helpers.c ecma-builtin-json.c ecma-builtin-map-prototype.c ecma-builtin-map.c ecma-builtin-math.c ecma-builtin-number-prototype.c ecma-builtin-number.c ecma-builtin-object-prototype.c ecma-builtin-object.c ecma-builtin-promise-prototype.c ecma-builtin-promise.c ecma-builtin-rangeerror-prototype.c ecma-builtin-rangeerror.c ecma-builtin-referenceerror-prototype.c ecma-builtin-referenceerror.c ecma-builtin-regexp-prototype.c ecma-builtin-regexp.c ecma-builtin-string-prototype.c ecma-builtin-string.c ecma-builtin-syntaxerror-prototype.c ecma-builtin-syntaxerror.c ecma-builtin-type-error-thrower.c ecma-builtin-typeerror-prototype.c ecma-builtin-typeerror.c ecma-builtin-urierror-prototype.c ecma-builtin-urierror.c ecma-builtins.c
    packages/jerryscript-latest/jerryscript/jerry-core/ecma/builtin-objects/typedarray/: ecma-builtin-float32array-prototype.c ecma-builtin-float32array.c ecma-builtin-float64array-prototype.c ecma-builtin-float64array.c ecma-builtin-int16array-prototype.c ecma-builtin-int16array.c ecma-builtin-int32array-prototype.c ecma-builtin-int32array.c ecma-builtin-int8array-prototype.c ecma-builtin-int8array.c ecma-builtin-typedarray-helpers.c ecma-builtin-typedarray-prototype.c ecma-builtin-typedarray.c ecma-builtin-uint16array-prototype.c ecma-builtin-uint16array.c ecma-builtin-uint32array-prototype.c ecma-builtin-uint32array.c ecma-builtin-uint8array-prototype.c ecma-builtin-uint8array.c ecma-builtin-uint8clampedarray-prototype.c ecma-builtin-uint8clampedarray.c
    packages/jerryscript-latest/jerryscript/jerry-core/ecma/operations/: ecma-array-object.c ecma-arraybuffer-object.c ecma-boolean-object.c ecma-comparison.c ecma-conversion.c ecma-eval.c ecma-exceptions.c ecma-function-object.c ecma-get-put-value.c ecma-jobqueue.c ecma-lex-env.c ecma-map-object.c ecma-number-arithmetic.c ecma-number-object.c ecma-objects-arguments.c ecma-objects-general.c ecma-objects.c ecma-promise-object.c ecma-reference.c ecma-regexp-object.c ecma-string-object.c ecma-typedarray-object.c
    packages/jerryscript-latest/jerryscript/jerry-core/jcontext/: jcontext.c
    packages/jerryscript-latest/jerryscript/jerry-core/jmem/: jmem-allocator.c jmem-heap.c jmem-poolman.c
    packages/jerryscript-latest/jerryscript/jerry-core/jrt/: jrt-fatals.c
    packages/jerryscript-latest/jerryscript/jerry-core/lit/: lit-char-helpers.c lit-magic-strings.c lit-strings.c
    packages/jerryscript-latest/jerryscript/jerry-core/parser/js/: byte-code.c common.c js-lexer.c js-parser-expr.c js-parser-mem.c js-parser-scanner.c js-parser-statm.c js-parser-util.c js-parser.c
    packages/jerryscript-latest/jerryscript/jerry-core/parser/regexp/: re-bytecode.c re-compiler.c re-parser.c
    packages/jerryscript-latest/jerryscript/jerry-core/vm/: opcodes-ecma-arithmetics.c opcodes-ecma-bitwise.c opcodes-ecma-relational-equality.c opcodes.c vm-stack.c vm-utils.c vm.c
    packages/jerryscript-latest/jerryscript/jerry-ext/arg/: arg-js-iterator-helper.c arg-transform-functions.c arg.c
    packages/jerryscript-latest/jerryscript/jerry-ext/handler/: handler-assert.c handler-gc.c handler-print.c handler-register.c
    packages/jerryscript-latest/jerryscript/jerry-ext/module/: module.c
  group JerryScriptPort
    packages/jerryscript-latest/rtthread-port/: jerry_buffer.c jerry_callbacks.c jerry_console.c jerry_event.c jerry_main.c jerry_message.c jerry_module.c jerry_mqtt.c jerry_net.c jerry_os.c jerry_request_init.c jerry_utf8.c jerry_util.c jerry_wlan.c port.c
  group LVGL-port
    packages/LVGL-v8.3-latest/env_support/rt-thread/: lv_port_disp.c lv_port_indev.c lv_rt_thread_port.c
  group LVGL
    packages/LVGL-v8.3-latest/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3-latest/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-v8.3-latest/src/extra/: lv_extra.c
    packages/LVGL-v8.3-latest/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-v8.3-latest/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3-latest/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-v8.3-latest/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3-latest/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3-latest/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3-latest/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3-latest/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3-latest/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    packages/LVGL-v8.3-latest/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3-latest/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3-latest/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    packages/LVGL-v8.3-latest/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3-latest/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3-latest/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3-latest/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3-latest/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3-latest/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3-latest/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3-latest/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3-latest/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3-latest/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3-latest/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3-latest/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3-latest/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3-latest/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3-latest/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3-latest/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3-latest/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3-latest/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3-latest/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3-latest/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3-latest/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3-latest/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3-latest/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3-latest/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3-latest/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3-latest/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3-latest/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3-latest/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3-latest/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3-latest/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3-latest/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3-latest/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3-latest/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3-latest/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3-latest/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3-latest/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3-latest/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3-latest/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3-latest/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.3-latest/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.3-latest/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    packages/LVGL-v8.3-latest/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.3-latest/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.3-latest/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    packages/LVGL-v8.3-latest/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    packages/LVGL-v8.3-latest/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group minIni
    packages/minIni-v1.2.0/dev/: minIni.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group xpt2046_touch
    packages/xpt2046-latest/: drv_xpt2046.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c pulse_encoder.c input_encoder.c input_ts.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi-bit-ops.c spi_ad9833.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Touch
    ../../../components/drivers/touch/: touch.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: mstorage.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group mod_dac
    ../../../components/utilities/mod_dac/: mod_dac.c
  group mod_input
    ../../../components/utilities/mod_input/: mod_input.c
  group mod_para
    ../../../components/utilities/mod_para/: mod_para.c
  group utils_list
    ../../../components/utilities/utils_list/: utils_list.c
  group Utilities
    ../../../components/utilities/ymodem/: ymodem.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_dsi.c
